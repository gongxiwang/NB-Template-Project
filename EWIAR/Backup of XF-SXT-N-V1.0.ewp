# IAR project Backup of XF-SXT-N-V1.0.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: LORA_MODULE
  ICCARM.CCIncludePath2: ..\UCOS-II\CPU\inc; ..\UCOS-II\uC-CPU\; ..\UCOS-II\uC-CPU\; ..\UCOS-II\uC-LIB; ..\UCOS-II\uC-OSII\Ports\; ..\UCOS-II\uC-OSII\Source; ..\USER\BSP; ..\USER\APP
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XF-SXT-N-V1.0.hex
  ILINK.IlinkOutputFile: XF-SXT-N-V01.out
  ILINK.IlinkIcfFile: E:\MYWorkPlace\SVNData\zhouwanli\XF-SXT-N-V1.0\USER\BSP\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FWLib/inc
    ../UCOS-II/CPU/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h
  group FWLib/src
    ../UCOS-II/CPU/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group UCOSII/uC/CPU
    ../UCOS-II/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_def.h
  group UCOSII/uC/LIB
    ../UCOS-II/uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOSII/uC/LIB/Ports
    ../UCOS-II/uC-LIB/Ports/: lib_mem_a.asm
  group UCOSII/uC/OS-II/Port
    ../UCOS-II/uC-OSII/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII/uC/OS-II/Source
    ../UCOS-II/uC-OSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group USER/APP
    ../USER/APP/: app.c app_adc.c app_adc.h app_beep.c app_beep.h app_cfg.h app_CO2.c app_device.c app_led.c app_led.h app_lora.c app_lora.h app_modbus.c app_nbiot.c app_nbiot.h App_RF13P56M.c App_RF900M.c app_uart.c app_uart.h app_vect_v5.c app_watmet.c includes.h os_cfg.h probe_com_cfg.h ringbuf.c ringbuf.h
  group USER/BSP
    ../USER/APP/: app_templg.c
    ../USER/BSP/: bsp.c bsp.h bsp_13p56m.c bsp_adc.c bsp_adc.h bsp_beep.c bsp_beep.h bsp_dma.c bsp_dma.h bsp_int.c bsp_key.c bsp_led.c bsp_led.h bsp_lora.c bsp_lora.h bsp_modbus.c bsp_nbiot.c bsp_nbiot.h bsp_periph.c bsp_uart.c bsp_uart.h STM32_FLASH.icf UHF_reader_Driver.c
